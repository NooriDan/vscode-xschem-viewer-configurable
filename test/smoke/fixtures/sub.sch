v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {sub.sch -- child schematic for the hierarchy-navigation smoke test} -20 -300 0 0 0.4 0.4 {}
C {devices/vsource.sym} 180 -220 0 0 {name=V9 value=0.9}
C {devices/gnd.sym} 180 -160 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 180 -280 0 0 {name=p9 sig_type=std_logic lab=SUBNET}
C {sg13g2_pr/sg13_lv_nmos.sym} 380 -220 0 0 {name=M9 w=1u l=0.13u ng=1 m=1}
